#ifdef WIN32

#include <windows.h>

// C RunTime Header Files
#include <stdlib.h>
#include <malloc.h>
//#include <memory.h>
#include <string.h>

#include "winstuff.h"
#include "backdrop.h"
#include "zbuffer.h"

extern char * loadedFile;

int APIENTRY WinMain(HINSTANCE hInstance, HINSTANCE hPrevInstance,
							LPSTR lpCmdLine, int nCmdShow) {
	MSG msg;

	// Do we exist already? Then throw ourselves over there...
	if (! hPrevInstance) if (! InitApplication (hInstance)) return false;

	if (! initBackDrop (640, 480)) return false;
	blankBackDrop ();
	if (lpCmdLine[0]) {
		if (! loadZBufferFile (lpCmdLine)) processZBufferData ();
		else loadedFile = copyString (lpCmdLine);
	} else {
		processZBufferData ();
	}

	// Finally, start the application...
	if (! InitInstance (hInstance, nCmdShow)) return false;

	// Handle all the input...
	while (GetMessage(&msg, NULL, 0, 0)) {
		TranslateMessage(&msg);
		DispatchMessage(&msg);
	};

	return (msg.wParam);

//	return 0;
}

#endif